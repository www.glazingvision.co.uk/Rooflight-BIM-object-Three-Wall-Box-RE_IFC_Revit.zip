Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-01-25T16:02:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed Jan 25 16:02:23 2017* Host: NCL-PI08* Database: C:\Users\KovacsG\AppData\Local\Temp\{FF2D3C9D-FAA7-44B4-B8E5-339CD1641DFA}\ifc* Database version: 5507* Database creation date: Wed Jan 25 16:02:22 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed Jan 25 16:02:22 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed Jan 25 16:02:22 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: X:\NBL\Manufacturer\G\Glazing Vision_12688\NBLA0680\Authoring\IFC\NBS_GlazingVisionLtd_FrmdRflghts_ThreeWallBoxRightExit.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcDoor: DoubleGlazed-2400x1200x1200mm_6-20-6mm, NBS_GlazingVisionLtd_FrmdRflghts_ThreeWallBoxRightExit:DoubleGlazed-2400x1200x1200mm_6-20-6mm:187828
In: Level 1
Type - ConstructionType: ALUMINIUM; ParameterTakesPrecedence: no; Sizeable: no; Classification: Pr_30_59_72_31 (Uniclass2015); Material: NBS_Concept, NBS_Glass_Double
Type - NBS_General - Author: NBS; BIMObjectName: NBS_GlazingVisionLtd_FramedRooflights_StandardThreeWallBoxRightExit_DoubleGlazed; ManufacturerName: Glazing Vision Ltd; ManufacturerURL: www.glazingvision.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/blbkam0q; NBSDescription: Framed rooflights; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-25-99/410; NBSTypeID: n/a; ProductInformation: www.glazingvision.co.uk/rooflights/box-rooflights/3-wall-box-rooflight/; Revision: n/a; Uniclass2015Code: Pr_30_59_72_31; Uniclass2015Title: Framed rooflights; Uniclass2015Version: Products v1.3; Version: 1
Type - NBS_Data - Accessories: Remote control, Rain sensor, Thermostat, BMS integration, RITEC coating, External mounted key switch, External keypad, Proximity detection, Battery back up; CavityType: 20 mm black silicone sealed warm edge argon filled; Certification: n/a; DriveMechanism: Twin rack and pinion drive with solenoid security one way clutch; Form: Three wall box; FrameFinishCoating: Qualicoat approved polyester powder coating; FrameFinishColour: RAL 7015 Grey (Outer), RAL 9010 White (Inner); FrameFinishTexture: n/a; FrameMaterial: Aluminium; GlazingOptions: Double, triple; GlazingOrInfillCoating: Low-e coating; GlazingOrInfillConstruction: Double glazed; GlazingOrInfillType: Insulating glass unit; InnerPaneType: 6 mm heat soak tested soft low e toughened; IntermediatePaneType: n/a; MaximumArea: 6.0 m²; MaximumSize: 4200 (width) x 2300 (span) x 1500 (height) mm; MinimumSize: 1500 (width) x 1100 (span) x 400 (height) mm; OpeningType: Sliding for access; OperationControl: OR control board and magnetic limit switches; OperationType: External 24 V, 14.6 A, 300 W switch mode power supply; OuterPaneType: 6 mm heat soak tested toughened; RooflightWeight: 240 kg (2400 x 1200 x 1200 mm); Seals: PVC coated foam sliding seal, silicone seal on closing edge; Security: Built in anti-lifting mechanism to prevent disengagement of drive mechanism via vertical movement of sliding frame; StructuralKerb: To builders kerb (by others) min 100 mm wide, 150 mm high; ThermalBreak: yes; WholeWindowUValue: 4.2 W/m²K Uw
Type - Pset_WindowCommon - AcousticRating: 31 db; FireRating: n/a; GlazingAreaFraction: 0; Infiltration: 0; IsExternal: yes; Reference: n/a; SecurityRating: n/a; SmokeStop: no; ThermalTransmittance: 4
Type - Pset_DoorWindowGlazingType - BeamRadiationTransmittance: 0; FillGas: Argon; GlassColor: Clear; GlassLayers: 2; GlassThickness1: 6 mm; GlassThickness2: 6 mm; GlassThickness3: 0 mm; IsCoated: yes; IsLaminated: no; IsTempered: yes; IsWired: no; Reflectivity: 0; SolarHeatGainTransmittance: 0; ThermalTransmittanceSummer: 0; ThermalTransmittanceWinter: 0; Translucency: 0
Type - Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 300; HasProtectiveEarth: no; InsulationStandardClass: n/a; IP_Code: n/a; NominalCurrent: 14.6; NominalFrequencyRange: n/a; NominalVoltage: 24 V; NumberOfPoles: 0; PhaseAngle: 0; PhaseReference: n/a; UsageCurrent: 14.6
Type - Pset_DoorCommon - FireExit: no; HandicapAccessible: no; SelfClosing: no
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_72_31: Framed rooflights; CodePerformance: n/a; Color: Grey/white frame, clear glass; Constituents: Aluminium frame, double IGU, sliding door; Description: Double glazed glass box for regular roof access designed to fix within walls of the building, sliding door retracts over fixed glazing; DurationUnit: year; ExpectedLife: n/a; Features: Approx 50% clear opening, suitable for regular access, one touch operation; Finish: n/a; Grade: n/a; Manufacturer: sales@glazingvision.co.uk; Material: Aluminium, glass; ModelNumber: 607; ModelReference: GV Double Glazed Standard Three Wall Box - Right Exit; Name: FramedRooflights_StandardThreeWallBoxRightExit_DoubleGlazed_GlazingVisionLtd; NominalHeight: 0 mm; NominalLength: 2400 mm; NominalWidth: 1200 mm; ReplacementCost: n/a; Shape: Box; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: Manufacturer's warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: customerservices@glazingvision.co.uk
OverallHeight: 1710.53 mm; OverallWidth: 2414.05 mm
NBS_Data - ComponentNumber: n/a; DoorNumber: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
